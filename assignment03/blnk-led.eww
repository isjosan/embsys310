<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\blnk-led.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\morse-code-led\morse-code-led.ewp</path>
    </project>
    <batchBuild />
</workspace>
